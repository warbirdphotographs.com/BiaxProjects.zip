simulink library "LibDynamics"  (Simulink 7.4)
settings: Solver=ode45  SolverMode=SingleTasking  StartTime=0.0  StopTime=10.0  RelTol=1e-3
values from neighbouring files (symbols this model uses):
  delay = ones(nTbl,1) * mean(valveDelay)    [analysis.m]
  dof = [1 2]    [initialize.m]    (also in accelEnvelope.m = varargin{1}{1}; displEnvelope.m = varargin{1}{1}; displPivotEnvelope.m = varargin{1}{1}; forceEnvelope.m = varargin{1}{2})
  flowCanon = 63090.2    [initialize.m]
  forceCanon = 0.00444822    [initialize.m]
  gasConstant = 1.8    [initialize.m]
  gee = geeCanon / linAccelCanon * 0    (= 0)    [initialize.m]    (also in accelA2T.m; accelEnvelope.m = varargin{1}{6}; accelT2A.m)
  inertia = inertia + inertiaP2Q([0 0 0], massA(i), cgA(:,i)-cg,  									inertiaCanon, massCanon)    [initialize.m]
  inertiaCanon = 2.9264264e-04    (= 0.00029264264)    [initialize.m]    (also in inertiaP2Q.m = 1)
  initDispl = zeros(6, 1)    [initialize.m]
  lengthCanon = 25.4    [initialize.m]
  linAccelCanon = 9810.0    (= 9810)    [initialize.m]    (also in accelJacobian.m = canon(3); accelP2Q.m = canon(3))
  linDisplCanon = 1    [initialize.m]    (also in displJacobian.m = canon(1); velocJacobian.m = canon(1))
  linVelocCanon = 1000.0    (= 1000)    [initialize.m]    (also in forceInvJacobian.m = canon(2); velocJacobian.m = canon(2); velocP2Q.m = canon(2))
  mass = ones(3, 1) * (sum(massA) + massT + massS)    [initialize.m]
  massCanon = 0.4535924e-06    (= 4.535924e-07)    [initialize.m]    (also in inertiaP2Q.m = 1)
  maxDispl = max(abs(maxDispl), abs(minDispl))    [initialize.m]    (also in Tutorial.m = 0.4)
  maxVeloc = max(abs(maxVeloc), abs(minVeloc))    [analysis.m]    (also in initialize.m; rampth.m = 2 * maxDispl / (nVeloc * deltaT); Tutorial.m = 1.234)
  modalCG = [1000 1000 0]    [initialize.m]
  modalDamp = [5 5 5]    [initialize.m]    (also in resondemo.m = eval(get(findobj(fig, 'Tag', 'modalDamp'), 'String')))
  modalFreq = [5 5 5]    [initialize.m]    (also in resondemo.m = tableFreq * freqRatio)
  modalMass = 50000    [initialize.m]    (also in resondemo.m = tableMass * massRatio)
  oilDamping = 2 * damping * 0.01 * 2 * pi .* oilColumn .* massQ * massCanon    [initialize.m]
  oilSpring = bulkModulus * pressCanon  			.* (area1 * areaCanon ./ length1 + area2 * areaCanon ./ length2)    [initialize.m]
  precharge = 2000    [initialize.m]
  pressCanon = 6.894758e-06    [initialize.m]
  pumpFlow = 1e10    (= 10000000000)    [initialize.m]
  rotAccelCanon = pi/180    (= 0.0174532925199)    [initialize.m]    (also in accelJacobian.m = canon(7); accelP2Q.m = canon(7); bodyAccel.m = canon(3); eulerAccel.m = canon(3))
  rotDisplCanon = pi/180    (= 0.0174532925199)    [initialize.m]    (also in accelA2T.m = canon(5); accelP2Q.m = canon(5); accelT2A.m = canon(5); bodyAccel.m = canon(1))
  rotForceCanon = 1000    [initialize.m]    (also in forceInvJacobian.m = canon(8); forceP2Q.m = canon(8))
  rotVelocCanon = pi/180    (= 0.0174532925199)    [initialize.m]    (also in accelJacobian.m = canon(6); accelP2Q.m = canon(6); bodyAccel.m = canon(2); eulerAccel.m = canon(2))
  samplePeriod = controlPeriod/upsampleFactor    (= 0.00048828125)    [initialize.m]    (also in viewer.m = eval(getHeaderValue(header, 'DELTA_T')))
  supplyPress = 3000    [initialize.m]
  vmax = ( (maxFlow' * flowCanon ./ (area1 * areaCanon)) / linVelocCanon)'    [initialize.m]
  volume = 160    [initialize.m]    (also in quake.m = volume / 231.0)
  volumeCanon = 3785412.0    (= 3785412)    [initialize.m]
undefined symbols (not defined in the file or in its folder): blowPress, blowRatedFlow, blowRatedPress, drive, drum, friction, gear, motDisplCanon, motor, motTorqueCanon, motVelocCanon, params, yieldDispl
libraries: LibDynamics x27, LibTransforms x12, aerospace x6, simulink x2
(part 2 of 2)

== system LibDynamics/inverse 6 DOF rigid body payload ==
  note: body rot rates
  note: body lin rates
  accel xyz : Inport  OutDataType=sfix(16)  OutScaling=2^0
  accel rpw : Inport  Port=2  OutDataType=sfix(16)  OutScaling=2^0
  Sum : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=++|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=|++  OutDataType=sfix(16)  OutScaling=2^0
  crossprod1 : aerospace/Axes Transformations/3x3 cross product  SystemSampleTime=-1
  crossprod2 : aerospace/Axes Transformations/3x3 cross product  SystemSampleTime=-1
  euler rate : LibTransforms/euler rate  SystemSampleTime=-1
  euler rot : LibTransforms/euler rot  SystemSampleTime=-1
  gravity : Constant  Value="[0 0 1]  * gee *  linAccelCanon"  OutDataType=sfix(16)  OutScaling=2^0
  inertia 1 : Gain  Gain=inertia*inertiaCanon  Multiplication=Matrix(K*u)  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  inertia 2 : Gain  Gain=inertia*inertiaCanon  Multiplication=Matrix(K*u)  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  lin displ gen : LibDynamics/bilinear integrator  SystemSampleTime=-1  initialCondition=initialPosition(1:3)  samplePeriod=samplePeriod
  lin veloc gen : LibDynamics/bilinear integrator  SystemSampleTime=-1  initialCondition=0  samplePeriod=samplePeriod
  linAccelCanon : Gain  Gain=linAccelCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  linVelocUnits : Gain  Gain=1/linVelocCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  mass : Gain  Gain=mass*massCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  rot displ gen : LibDynamics/bilinear integrator  SystemSampleTime=-1  initialCondition=initialPosition(4:6)  samplePeriod=samplePeriod
  rot veloc gen : LibDynamics/bilinear integrator  SystemSampleTime=-1  initialCondition=0  samplePeriod=samplePeriod
  rotAccelCanon : Gain  Gain=rotAccelCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  rotForceUnits : Gain  Gain=1/rotForceCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  rotVelocUnits : Gain  Gain=1/rotVelocCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  to body frame : Product  Multiplication=Matrix(*)  OutDataType=sfix(16)  OutScaling=2^0
  to inertial frame : Product  Multiplication=Matrix(*)  OutDataType=sfix(16)  OutScaling=2^0
  transpose : Math  Operator=transpose  OutDataType=sfix(16)  OutScaling=2^0
  unit dly 1 : UnitDelay  SampleTime=-1
  unit dly 2 : UnitDelay  SampleTime=-1
  unit dly 3 : UnitDelay  X0=initialPosition(4:6)  SampleTime=-1
  displ xyz : Outport  OutDataType=sfix(16)  OutScaling=2^0
  displ rpw : Outport  Port=2  OutDataType=sfix(16)  OutScaling=2^0
  veloc xyz : Outport  Port=3  OutDataType=sfix(16)  OutScaling=2^0
  veloc rpw : Outport  Port=4  OutDataType=sfix(16)  OutScaling=2^0
  force xyz : Outport  Port=5  OutDataType=sfix(16)  OutScaling=2^0
  force rpw : Outport  Port=6  OutDataType=sfix(16)  OutScaling=2^0
  DCM : Outport  Port=7  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  linAccelCanon/1 -> to body frame/2, Sum1/2
  Sum1/1 -> mass/1
  mass/1 -> force xyz/1
  accel xyz/1 -> linAccelCanon/1
  Sum2/1 -> rotForceUnits/1
  rotForceUnits/1 -> force rpw/1
  inertia 1/1 -> Sum2/1
  rotAccelCanon/1 -> inertia 1/1, rot veloc gen/1
  accel rpw/1 -> rotAccelCanon/1
  to body frame/1 -> Sum/1
  gravity/1 -> Sum1/1
  crossprod1/1 -> unit dly 1/1
  transpose/1 -> to inertial frame/1
  to inertial frame/1 -> linVelocUnits/1, lin displ gen/1
  linVelocUnits/1 -> veloc xyz/1
  inertia 2/1 -> crossprod2/2
  rotVelocUnits/1 -> veloc rpw/1, euler rate/1
  rot displ gen/1 -> displ rpw/1, unit dly 3/1, euler rot/1  "euler angles"
  crossprod2/1 -> unit dly 2/1
  Sum/1 -> lin veloc gen/1
  lin displ gen/1 -> displ xyz/1
  euler rot/1 -> DCM/1, transpose/1, to body frame/1
  euler rate/1 -> rot displ gen/1  "euler rates"
  lin veloc gen/1 -> crossprod1/1, to inertial frame/2
  rot veloc gen/1 -> inertia 2/1, crossprod2/1, rotVelocUnits/1, crossprod1/2
  unit dly 1/1 -> Sum/2
  unit dly 2/1 -> Sum2/2
  unit dly 3/1 -> euler rate/2

== system LibDynamics/inverse 6 DOF rigid body payload (displ input) ==
  note: body rot rates
  note: body lin rates
  displ xyz : Inport  OutDataType=sfix(16)  OutScaling=2^0
  displ rpw : Inport  Port=2  OutDataType=sfix(16)  OutScaling=2^0
  Sum : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  Sum1 : Sum  Inputs=++|  OutDataType=sfix(16)  OutScaling=2^0
  Sum2 : Sum  Inputs=++|  OutDataType=sfix(16)  OutScaling=2^0
  body rate : LibTransforms/body rate  SystemSampleTime=-1
  crossprod1 : aerospace/Axes Transformations/3x3 cross product  SystemSampleTime=-1
  crossprod2 : aerospace/Axes Transformations/3x3 cross product  SystemSampleTime=-1
  euler rot : LibTransforms/euler rot  SystemSampleTime=-1
  gravity : Constant  Value="[0 0 1]  * gee *  linAccelCanon"  OutDataType=sfix(16)  OutScaling=2^0
  inertia 1 : Gain  Gain=inertia*inertiaCanon  Multiplication=Matrix(K*u)  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  inertia 2 : Gain  Gain=inertia*inertiaCanon  Multiplication=Matrix(K*u)  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  lin accel gen : LibDynamics/bilinear derivative  SystemSampleTime=-1  decay=0.9  initialCondition=0  samplePeriod=samplePeriod
  lin veloc gen : LibDynamics/bilinear derivative  SystemSampleTime=-1  decay=0.9  initialCondition=initialPosition(1:3)  samplePeriod=samplePeriod
  linAccelUnits : Gain  Gain=1/linAccelCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  linVelocUnits : Gain  Gain=1/linVelocCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  mass : Gain  Gain=mass*massCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  rot accel gen : LibDynamics/bilinear derivative  SystemSampleTime=-1  decay=0.9  initialCondition=0  samplePeriod=samplePeriod
  rot veloc gen : LibDynamics/bilinear derivative  SystemSampleTime=-1  decay=0.9  initialCondition=initialPosition(4:6)  samplePeriod=samplePeriod
  rotAccelUnits : Gain  Gain=1/rotAccelCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  rotForceUnits : Gain  Gain=1/rotForceCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  rotVelocCanon : Gain  Gain=rotVelocCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  to body frame : Product  Multiplication=Matrix(*)  OutDataType=sfix(16)  OutScaling=2^0
  to inertial frame : Product  Multiplication=Matrix(*)  OutDataType=sfix(16)  OutScaling=2^0
  transpose : Math  Operator=transpose  OutDataType=sfix(16)  OutScaling=2^0
  veloc xyz : Outport  OutDataType=sfix(16)  OutScaling=2^0
  veloc rpw : Outport  Port=2  OutDataType=sfix(16)  OutScaling=2^0
  accel xyz : Outport  Port=3  OutDataType=sfix(16)  OutScaling=2^0
  accel rpw : Outport  Port=4  OutDataType=sfix(16)  OutScaling=2^0
  force xyz : Outport  Port=5  OutDataType=sfix(16)  OutScaling=2^0
  force rpw : Outport  Port=6  OutDataType=sfix(16)  OutScaling=2^0
  DCM : Outport  Port=7  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  body rate/1 -> rotVelocCanon/1, veloc rpw/1
  rot veloc gen/1 -> body rate/1  "euler rates"
  crossprod2/1 -> Sum2/1
  inertia 1/1 -> Sum2/2
  Sum2/1 -> rotForceUnits/1
  inertia 2/1 -> crossprod2/2
  rot accel gen/1 -> rotAccelUnits/1, inertia 1/1
  rotAccelUnits/1 -> accel rpw/1
  mass/1 -> force xyz/1
  gravity/1 -> Sum1/1
  Sum1/1 -> mass/1
  linAccelUnits/1 -> accel xyz/1
  to inertial frame/1 -> Sum1/2, linAccelUnits/1
  Sum/1 -> to inertial frame/2
  transpose/1 -> to inertial frame/1
  crossprod1/1 -> Sum/2
  lin accel gen/1 -> Sum/1
  rotVelocCanon/1 -> rot accel gen/1, inertia 2/1, crossprod2/1, crossprod1/2
  to body frame/1 -> lin accel gen/1, crossprod1/1
  lin veloc gen/1 -> to body frame/2, linVelocUnits/1
  displ xyz/1 -> lin veloc gen/1
  rotForceUnits/1 -> force rpw/1
  linVelocUnits/1 -> veloc xyz/1
  displ rpw/1 -> body rate/2, rot veloc gen/1, euler rot/1  "euler angles"
  euler rot/1 -> transpose/1, DCM/1, to body frame/1

== system LibDynamics/inverse actuator ==
  note: Parameter vector: 1: oil bulk modulus (force/displ^2) 2: servovalve delay (sec) 3: servovalve overlap 4: rated pressure (force/displ^2) 5: rated flow at rated pressure (displ^3/sec) 6: nominal flow at rated pressure (displ^3/sec) 7: actuator piston area 1 (displ^2) 8: actuator piston area 2 (displ^2) 9: actuator usable stroke 1 (displ) 10: actuator usable stroke 2 (displ) 11: actuator end cushion length 1 (displ) 12: actuator end cushion length 2 (displ) 13: additional port volume 1 (displ^3) 14: additional port volume 2 (displ^3) 15: actuator parasitic damping factor 16: cross-chamber leakage factor (flow/press) 17: ratio port openings according to area 18: sample period (sec) Conversion factors used for converting signals from external (user) to internal (canonical) units: 19: displacement 20: velocity 21: force 22: pressure 23: flow Other: 24: delta-F feedback gain 25: inverse solver (0: exact, 1: approx)
  note: Auxiliary diagnostic output vector: 1: valve opening 2: delta pressure 3: supply flow 4: return flow 5: C1 pressure 6: C2 pressure 7: C1 flow 8: C2 flow 9: C1 oilspring displacement 10: C2 oilspring displacement 11: C1 oilspring velocity 12: C2 oilspring velocity 13: iteration error
  note: Note: "1" and "2" denote actuator cylinders on either side of the actuator piston. With positive valve drive, oil is ported into cylinder 1, resulting in positive displacement.
  displ : Inport  OutDataType=sfix(16)  OutScaling=2^0
  veloc : Inport  Port=2  OutDataType=sfix(16)  OutScaling=2^0
  force : Inport  Port=3  OutDataType=sfix(16)  OutScaling=2^0
  spl press : Inport  Port=4  OutDataType=sfix(16)  OutScaling=2^0
  rtn press : Inport  Port=5  OutDataType=sfix(16)  OutScaling=2^0
  invactuator : S-Function  FunctionName=InvActuator  Parameters=params  EnableBusSupport=off
  supply flow sel : Selector  IndexOptions=Index vector (dialog)  Indices=3  OutputSizes=1
  cmd : Outport  OutDataType=sfix(16)  OutScaling=2^0
  flow : Outport  Port=2  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  spl press/1 -> invactuator/4
  rtn press/1 -> invactuator/5
  displ/1 -> invactuator/1
  invactuator/1 -> cmd/1
  veloc/1 -> invactuator/2
  force/1 -> invactuator/3
  invactuator/2 -> supply flow sel/1
  supply flow sel/1 -> flow/1

== system LibDynamics/modal point mass ==
  accel xyz : Inport  OutDataType=sfix(16)  OutScaling=2^0
  accel rpw : Inport  Port=2  OutDataType=sfix(16)  OutScaling=2^0
  DCM : Inport  Port=3  OutDataType=sfix(16)  OutScaling=2^0
  veloc rpw : Inport  Port=4  OutDataType=sfix(16)  OutScaling=2^0
  Demux : Demux  Outputs=3
  Mux : Mux  Inputs=3
  Sum2 : Sum  Inputs=++|  OutDataType=sfix(16)  OutScaling=2^0
  accelT2S : LibTransforms/accelP2Q  SystemSampleTime=-1  dof=1:6  ofst=ofst
  ax : DiscreteFilter  Numerator=b(1,:)  Denominator=a(1,:)
  ay : DiscreteFilter  Numerator=b(2,:)  Denominator=a(2,:)
  az : DiscreteFilter  Numerator=b(3,:)  Denominator=a(3,:)
  forceS2T : LibTransforms/forceP2Q  SystemSampleTime=-1  dof=1:6  ofst=-ofst
  frpw : Constant  Value=[0 0 0]  OutDataType=sfix(16)  OutScaling=2^0
  linAccelCanon : Gain  Gain=linAccelCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  mass : Gain  Gain=mass*massCanon  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  weight : Constant  Value="[0 0 1]  * modalMass * massCanon * gee * linAccelCanon"  OutDataType=sfix(16)  OutScaling=2^0
  force xyz : Outport  OutDataType=sfix(16)  OutScaling=2^0
  force rpw : Outport  Port=2  OutDataType=sfix(16)  OutScaling=2^0
  accel_xyz : Outport  Port=3  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Mux/1 -> accel_xyz/1, linAccelCanon/1
  mass/1 -> Sum2/2
  accelT2S/1 -> Demux/1
  weight/1 -> Sum2/1
  Sum2/1 -> forceS2T/1, force xyz/1
  accel xyz/1 -> accelT2S/1
  linAccelCanon/1 -> mass/1
  Demux/1 -> ax/1
  Demux/2 -> ay/1
  Demux/3 -> az/1
  az/1 -> Mux/3
  ay/1 -> Mux/2
  ax/1 -> Mux/1
  frpw/1 -> forceS2T/2
  forceS2T/1 -> force rpw/1
  DCM/1 -> forceS2T/3, accelT2S/3
  accel rpw/1 -> accelT2S/2
  veloc rpw/1 -> accelT2S/4

== system LibDynamics/Rockwell PowerFlex 700S AC Drive and Motor/current regulator ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  inp/1 -> out/1

== system LibDynamics/Rockwell PowerFlex 700S AC Drive and Motor/inertia adaptation ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  derivative : LibDynamics/euler derivative  samplePeriod=samplePeriod
  gain : Gain  Gain=TotalInertia9*InertAdaptGain134*InertAdaptSel132  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  lowpass filter : DiscreteFilter  Numerator=[InertAdaptBW133*samplePeriod]  Denominator=[1 -(1-InertAdaptBW133*samplePeriod)]
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  lowpass filter/1 -> gain/1
  derivative/1 -> lowpass filter/1
  inp/1 -> derivative/1
  gain/1 -> out/1

== system LibDynamics/Rockwell PowerFlex 700S AC Drive and Motor/inertia compensation ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  auxiliary feedfwd gain : Gain  Gain=SpdTrim3Scale24  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  derivative : LibDynamics/euler derivative  samplePeriod=samplePeriod
  primary feedfwd gain : Gain  Gain=TotalInertia9*InertAccelGain57  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  aux : Outport  Port=2  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  auxiliary feedfwd gain/1 -> aux/1
  inp/1 -> derivative/1
  derivative/1 -> auxiliary feedfwd gain/1, primary feedfwd gain/1
  primary feedfwd gain/1 -> out/1

== system LibDynamics/Rockwell PowerFlex 700S AC Drive and Motor/lead/lag filter ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  discrete filter : DiscreteFilter  Numerator=b  Denominator=a
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  inp/1 -> discrete filter/1
  discrete filter/1 -> out/1

== system LibDynamics/Rockwell PowerFlex 700S AC Drive and Motor/notch filter ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Discrete Filter : DiscreteFilter  Numerator=b  Denominator=a
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Discrete Filter/1 -> out/1
  inp/1 -> Discrete Filter/1

== system LibDynamics/Rockwell PowerFlex 700S AC Drive and Motor/veloc error filter ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  discrete filter : DiscreteFilter  Numerator=b  Denominator=a
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  inp/1 -> discrete filter/1
  discrete filter/1 -> out/1

== system LibDynamics/Rockwell PowerFlex 700S AC Drive and Motor/veloc feedfwd filter ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  discrete filter : DiscreteFilter  Numerator=b  Denominator=a
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  discrete filter/1 -> out/1
  inp/1 -> discrete filter/1

== system LibDynamics/Rockwell PowerFlex 700S AC Drive and Motor/velocity observer ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Gain : Gain  Gain=1/(samplePeriod*encFilterLength)  ParameterDataType=sfix(16)  ParameterScaling=2^0  OutDataType=sfix(16)  OutScaling=2^0
  Sum : Sum  Inputs=|+-  OutDataType=sfix(16)  OutScaling=2^0
  delay : simulink/Discrete/Integer Delay  vinit=initDispl*displCanon/(baseSpeed*velocCanon)  samptime=-1  NumDelays=encFilterLength
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Gain/1 -> out/1
  Sum/1 -> Gain/1
  delay/1 -> Sum/2
  inp/1 -> delay/1, Sum/1

== system LibDynamics/blowdown/pressure drop ==
  flow : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Unit Delay : UnitDelay  SampleTime=-1
  pressure gain : Gain  Gain=ratedPress/ratedFlow^2  ParameterDataType=fixdt(1, 16)  ParameterScaling=2^0  OutDataType=fixdt(1, 16)  OutScaling=2^0
  square : Product  OutDataType=fixdt(1, 16)  OutScaling=2^0
  dpress : Outport
  wires:
  Unit Delay/1 -> dpress/1
  flow/1 -> square/2, square/1
  pressure gain/1 -> Unit Delay/1
  square/1 -> pressure gain/1

== system LibDynamics/displ2Accel/lowpass filter ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  Demux : Demux  Outputs=6
  Mux1 : Mux  Inputs=6
  lowpass filter 1 : Subsystem  mask(Butterworth Lowpass Filter){freq=freq, order=order, samplePeriod=samplePeriod}
      mask prompts: freq "Cutoff frequency (Hz)"; order "Filter order"; samplePeriod "Sample period (sec)"
      mask init:
      | if (0<order) && (freq < samplePeriod/2)
      | 	[b, a] = butter(order, 2*freq*samplePeriod);
      | else
      | 	b = [1];
      | 	a = [1];
      | end
  lowpass filter 2 : Subsystem  mask(Butterworth Lowpass Filter){freq=freq, order=order, samplePeriod=samplePeriod}
      mask prompts: freq "Cutoff frequency (Hz)"; order "Filter order"; samplePeriod "Sample period (sec)"
      mask init:
      | if (0<order) && (freq < samplePeriod/2)
      | 	[b, a] = butter(order, 2*freq*samplePeriod);
      | else
      | 	b = [1];
      | 	a = [1];
      | end
  lowpass filter 3 : Subsystem  mask(Butterworth Lowpass Filter){freq=freq, order=order, samplePeriod=samplePeriod}
      mask prompts: freq "Cutoff frequency (Hz)"; order "Filter order"; samplePeriod "Sample period (sec)"
      mask init:
      | if (0<order) && (freq < samplePeriod/2)
      | 	[b, a] = butter(order, 2*freq*samplePeriod);
      | else
      | 	b = [1];
      | 	a = [1];
      | end
  lowpass filter 4 : Subsystem  mask(Butterworth Lowpass Filter){freq=freq, order=order, samplePeriod=samplePeriod}
      mask prompts: freq "Cutoff frequency (Hz)"; order "Filter order"; samplePeriod "Sample period (sec)"
      mask init:
      | if (0<order) && (freq < samplePeriod/2)
      | 	[b, a] = butter(order, 2*freq*samplePeriod);
      | else
      | 	b = [1];
      | 	a = [1];
      | end
  lowpass filter 5 : Subsystem  mask(Butterworth Lowpass Filter){freq=freq, order=order, samplePeriod=samplePeriod}
      mask prompts: freq "Cutoff frequency (Hz)"; order "Filter order"; samplePeriod "Sample period (sec)"
      mask init:
      | if (0<order) && (freq < samplePeriod/2)
      | 	[b, a] = butter(order, 2*freq*samplePeriod);
      | else
      | 	b = [1];
      | 	a = [1];
      | end
  lowpass filter 6 : Subsystem  mask(Butterworth Lowpass Filter){freq=freq, order=order, samplePeriod=samplePeriod}
      mask prompts: freq "Cutoff frequency (Hz)"; order "Filter order"; samplePeriod "Sample period (sec)"
      mask init:
      | if (0<order) && (freq < samplePeriod/2)
      | 	[b, a] = butter(order, 2*freq*samplePeriod);
      | else
      | 	b = [1];
      | 	a = [1];
      | end
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  Mux1/1 -> out/1
  inp/1 -> Demux/1
  lowpass filter 6/1(out) -> Mux1/6
  lowpass filter 5/1(out) -> Mux1/5
  lowpass filter 4/1(out) -> Mux1/4
  lowpass filter 3/1(out) -> Mux1/3
  lowpass filter 2/1(out) -> Mux1/2
  lowpass filter 1/1(out) -> Mux1/1
  Demux/6 -> lowpass filter 6/1(inp)
  Demux/5 -> lowpass filter 5/1(inp)
  Demux/4 -> lowpass filter 4/1(inp)
  Demux/3 -> lowpass filter 3/1(inp)
  Demux/2 -> lowpass filter 2/1(inp)
  Demux/1 -> lowpass filter 1/1(inp)

== system LibDynamics/displ2Accel/lowpass filter/lowpass filter 1 ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  lowpass : DiscreteFilter  Numerator=b  Denominator=a  SampleTime=samplePeriod
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  inp/1 -> lowpass/1
  lowpass/1 -> out/1

== system LibDynamics/displ2Accel/lowpass filter/lowpass filter 2 ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  lowpass : DiscreteFilter  Numerator=b  Denominator=a  SampleTime=samplePeriod
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  lowpass/1 -> out/1
  inp/1 -> lowpass/1

== system LibDynamics/displ2Accel/lowpass filter/lowpass filter 3 ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  lowpass : DiscreteFilter  Numerator=b  Denominator=a  SampleTime=samplePeriod
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  inp/1 -> lowpass/1
  lowpass/1 -> out/1

== system LibDynamics/displ2Accel/lowpass filter/lowpass filter 4 ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  lowpass : DiscreteFilter  Numerator=b  Denominator=a  SampleTime=samplePeriod
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  lowpass/1 -> out/1
  inp/1 -> lowpass/1

== system LibDynamics/displ2Accel/lowpass filter/lowpass filter 5 ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  lowpass : DiscreteFilter  Numerator=b  Denominator=a  SampleTime=samplePeriod
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  inp/1 -> lowpass/1
  lowpass/1 -> out/1

== system LibDynamics/displ2Accel/lowpass filter/lowpass filter 6 ==
  inp : Inport  OutDataType=sfix(16)  OutScaling=2^0
  lowpass : DiscreteFilter  Numerator=b  Denominator=a  SampleTime=samplePeriod
  out : Outport  OutDataType=sfix(16)  OutScaling=2^0
  wires:
  lowpass/1 -> out/1
  inp/1 -> lowpass/1
